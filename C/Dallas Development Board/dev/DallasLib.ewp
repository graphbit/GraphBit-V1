# IAR project DallasLib.ewp, settings and files
configuration Debug (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Maxim (Dallas Semiconductor)\DS89C450.i51
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: Inc; Src; C:\Program Files (x86)\IAR Systems\Embedded Workbench 6.4\8051\inc\dlib\c
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  XLINK.XclFile: C:\Google_Drive\Projet_Session_6-Controleur_Ecran\Logiciel\Librairie Dallas\lnk51ew_DS89C450.xcl
configuration Release (8051)
  as the first configuration, except:
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\
  General.RTConfigPath: xxx.h
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  XLINK.XclFile: lnk0t.xcl
  group (top)
    src/: LCD.c
    ./: main.c
